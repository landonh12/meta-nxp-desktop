## conf/machine/imx93evkdesktop.conf
```bitbake
MACHINE="imx93evk"
require conf/machine/imx93evk.conf

require conf/machine/include/ubuntubasics.inc
```
